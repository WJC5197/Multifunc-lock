# Keil uVision project PMPDataT.uvproj, settings and files
target PMPDataT (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: PMPDataT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SRC
  group Source
    ./: PMPDataT.c
    ./SRC/: ctrl.c ds1302.c EEPROM.C lcd.c temp.c uart.c timer.c rc522.c
