# Keil uVision project PMPDataR.uvproj, settings and files
target PMPDataR (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: PMPDataR +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SRC
  group Source
    ./: PMPDataR.c
    ./SRC/: StepperMotorControl.c oled.c EEPROM.C uart.c FPM10A.c PlayMusic.c
